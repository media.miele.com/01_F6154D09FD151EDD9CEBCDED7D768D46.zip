Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-03-22T14:54:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 22 14:54:35 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\c6df529e-bb96-49c4-bd5c-2a4e7407ca0a\649c339f-c947-42fb-8265-c108efc748f9\ifc * Database version: 5507 * Database creation date: Tue Mar 22 14:54:34 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 22 14:54:34 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 22 14:54:34 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11882320_AE_TWV780WP_LW:12WV7802_AE_11882320_TWV780WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 12WV7802_AE_11882320_TWV780WP_LW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 12WV7802_AE_11882320_TWV780WP_LW
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 643 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_Alusilver, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Steel_Hight_Gloss_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_359875
Description: Flow; FlowDirection: SOURCEANDSINK
